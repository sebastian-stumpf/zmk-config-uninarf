## config/boards/shields/uninarf/Kconfig.defconfig
```kconfig
if UNINARF

config ZMK_KEYBOARD_NAME
    default "uninarf"

config SPI
    default y


endif
```
